# Keil uVision project STM32F1T8.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1T8
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries;..\Hardware;..\CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c
  group Lib
    ../Libraries/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_spi.c
  group HardWare
    ../Hardware/: adc.c can.c delay.c PID.c pwm.c svpwm.c transform.c spi.c
  group CM
    ../CM3/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
